# IAR project Start_LM3S6965.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc; Application\Display\; Setup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: Start_LM3S6965.out
  ILINK.IlinkIcfFile: Setup\LM3S6965_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: OS_Start2TasksDisplay.c
  group Application/Display
    Application/Display/: driverlib.a osram128x64x4.c
  group Application/Excluded
    Application/: OS_EventObject.c OS_ExtendedTask.c OS_ExtendTaskContext.c OS_Mailbox.c OS_MeasureCPU_Performance.c OS_MeasureCST_HRTimer_embOSView.c OS_MeasureCST_HRTimer_Printf.c OS_MeasureCST_Scope.c OS_Queue.c OS_RSemaphore.c OS_Start2Tasks.c OS_Start2Tasks.cpp OS_Start2TasksEx.c OS_StartLEDBlink.c OS_SWTimer.c OS_ThreadLocalStorage.c
  group Lib
    Lib/: os7m_tl__dp.a os7m_tl__r.a
  group Setup
    Setup/: HardFaultHandler.S JLINKMEM_Process.c LM3S6965_FLASH.icf OS_Error.c RTOSInit_LM3S6965.c RTOSVect.c SEGGER_HardFaultHandler.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c xmtx.c xmtx2.c
  group Setup/Excluded
    Setup/: SEGGER_RTT_Syscalls_IAR.c
