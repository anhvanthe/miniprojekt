<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start_LM3S6965.ewp</path>
  </project>
  <batchBuild/>
</workspace>


