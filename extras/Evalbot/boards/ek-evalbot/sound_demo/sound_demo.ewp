# IAR project sound_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B92 TexasInstruments LM3S9B92
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..
  OBJCOPY.OOCOutputFile: sound_demo.bin
  ILINK.IlinkOutputFile: sound_demo.out
  ILINK.IlinkIcfFile: sound_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ../drivers/: dac.c display96x16x1.c io.c sensors.c sound.c wav.c
    ./: sound_demo.c sound_demo.icf sounds.c startup_ewarm.c
    ../../../utils/: ustdlib.c
