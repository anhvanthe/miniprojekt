# IAR project miniprojekt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; PART_LM3S6965; TARGET_IS_FURY_RA1
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\RTOS\SEGGER\TI\LM3S6965\Start_LM3S6965\Application\Display
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: miniprojekt.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\RTOS\SEGGER\TI\LM3S6965\Start_LM3S6965\Application\Display\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
    $EW_DIR$/arm/RTOS/SEGGER/TI/LM3S6965/Start_LM3S6965/Application/Display/: osram128x64x4.c rit128x96x4.c
